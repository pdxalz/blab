## build/Kconfig/Kconfig.shield
```kconfig
osource "c:/users/pdxal/projects/blab/boards/shields/*/Kconfig.shield"
osource "C:/ncs/v2.2.0/nrf/boards/shields/*/Kconfig.shield"
```
